<?xml version="1.0" encoding="iso-8859-1"?>

<workspace>
  <project>
    <path>$WS_DIR$\..\..\3.Project_APhi_Navigator\4.Project_Build\APhi_Navigator.ewp</path>
  </project>
  <batchBuild/>
</workspace>


